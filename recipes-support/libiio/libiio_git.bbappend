SRC_URI = "git://github.com/analogdevicesinc/libiio.git;protocol=https;branch=main"
PV = "0.21+git${SRCPV}"
SRCREV = "fb64aca8adcaa607b482091b23b8edf10e5c1ad8"
