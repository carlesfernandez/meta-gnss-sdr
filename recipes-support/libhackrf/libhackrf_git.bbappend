SRC_URI = "git://github.com/mossmann/hackrf.git;branch=master;protocol=https"
