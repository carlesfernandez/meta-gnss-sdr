SRC_URI = "git://github.com/google/re2.git;branch=main;protocol=https"
