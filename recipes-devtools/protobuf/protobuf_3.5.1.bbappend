SRC_URI = "git://github.com/protocolbuffers/protobuf.git;protocol=https;branch=master"
