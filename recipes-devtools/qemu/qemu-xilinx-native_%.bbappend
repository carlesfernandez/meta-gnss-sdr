PACKAGECONFIG[png] = ",,libpng"
