INSANE_SKIP:${PN}-common += "textrel"