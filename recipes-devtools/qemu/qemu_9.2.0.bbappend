DEPENDS +=  "bash"