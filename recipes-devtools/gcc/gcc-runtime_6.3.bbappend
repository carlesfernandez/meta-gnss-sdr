FILES_${PN}-dev += " \
 /usr/lib/libgfortran.so.3.0.0 \
 /usr/lib/libgfortran.so \
 /usr/lib/libgfortran.spec \
 /usr/lib/libgfortran.a \
 /usr/lib/libgfortran.so.3 \
 /usr/lib/gcc/arm-oe-linux-gnueabi/6.3.0/libcaf_single.a \
 /usr/lib/gcc/arm-oe-linux-gnueabi/6.3.0/finclude \
 /usr/lib/gcc/arm-oe-linux-gnueabi/6.3.0/finclude/ieee_features.mod \
 /usr/lib/gcc/arm-oe-linux-gnueabi/6.3.0/finclude/ieee_exceptions.mod \
 /usr/lib/gcc/arm-oe-linux-gnueabi/6.3.0/finclude/ieee_arithmetic.mod \
"
