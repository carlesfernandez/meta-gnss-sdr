FILES_${PN}-dev += "\
${libdir}/gcc/${TARGET_SYS}/${BINV}/finclude/ \
"
