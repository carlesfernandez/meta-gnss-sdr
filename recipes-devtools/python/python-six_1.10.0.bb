inherit setuptools
require python-six.inc

