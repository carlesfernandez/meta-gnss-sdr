SUMMARY = "C++ linear algebra library"
HOMEPAGE = "http://arma.sourceforge.net/"
LICENSE = "MPL-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=cfd7d66d2864c38232ec1ef20b27c13a"
SRC_URI = "http://sourceforge.net/projects/arma/files/armadillo-7.600.1.tar.xz"

SRC_URI[md5sum] = "7edc68972ad5f0121efcd1173551d9a1"
SRC_URI[sha256sum] = "f3a35c2a56dc706e9c413438d5b3063a0df2141515efaf2d1170d1944573afb7"

inherit cmake 


