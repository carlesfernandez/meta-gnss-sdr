FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://psplash-geniux-img.h;outsuffix=default"
