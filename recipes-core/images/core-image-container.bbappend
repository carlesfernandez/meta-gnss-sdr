IMAGE_INSTALL = " \
                 packagegroup-core-container \
                 packagegroup-gnss-sdr-base \
                "
 
COMPATIBLE_MACHINE = "${MACHINE}"
