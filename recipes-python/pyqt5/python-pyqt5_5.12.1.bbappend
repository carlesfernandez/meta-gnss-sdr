MIRRORS_prepend () {
    https://www.riverbankcomputing.com/static/Downloads/PyQt5/${PV}/ https://distfiles.macports.org/py-pyqt5
    https://www.riverbankcomputing.com/static/Downloads/PyQt5/${PV}/ https://mirrors.cloud.tencent.com/macports/distfiles/py-pyqt5/
    https://www.riverbankcomputing.com/static/Downloads/PyQt5/${PV}/ http://cdimage.debian.org/mirror/kde.org/files/krita/build/dependencies/
    https://www.riverbankcomputing.com/static/Downloads/PyQt5/${PV}/ http://www.mirrors.ukfast.co.uk/sites/kde.org/files/krita/build/dependencies/
    https://www.riverbankcomputing.com/static/Downloads/PyQt5/${PV}/ http://ftp.informatik.uni-frankfurt.de/gentoo.org/distfiles/
}
