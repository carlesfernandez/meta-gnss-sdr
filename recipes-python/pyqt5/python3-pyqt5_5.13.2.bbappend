SRC_URI = "\
    http://mirror.sov.uk.goscomb.net/gentoo/distfiles/PyQt5-${PV}.tar.gz \
"
