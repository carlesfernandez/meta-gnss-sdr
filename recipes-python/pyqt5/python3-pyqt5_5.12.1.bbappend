SRC_URI = "\
    https://distfiles.macports.org/py-pyqt5/PyQt5_gpl-${PV}.tar.gz \
"
