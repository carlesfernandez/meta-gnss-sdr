SRC_URI = "git://salsa.debian.org/debian/resolvconf.git;branch=ubuntu;protocol=https \
           file://fix-path-for-busybox.patch \
           file://99_resolvconf \
          "
