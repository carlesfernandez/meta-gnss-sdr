# Manually download the file mali-400-userspace.tar from
# https://www.xilinx.com/products/design-tools/embedded-software/petalinux-sdk.html#licensing
# (link labelled "Download Mali-400 User Space Components"), and put it in your
# mirror or downloads folder

# Checksum in Xilinx recipe appears to be wrong
SRC_URI[md5sum] = "8b5b44b3f39f8662ed2755296865bb99"
SRC_URI[sha256sum] = "2fe9f3da94f19ba6a74d7da32f4c719ffddd31e38ada3be167884eba510da0f2"
