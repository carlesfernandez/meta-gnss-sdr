MIRRORS_prepend () {
    http://ftp.mozilla.org/pub/mozilla.org/js/ https://releases.mozilla.org/pub/js/
    http://ftp.mozilla.org/pub/mozilla.org/js/ http://ftp.oregonstate.edu/.1/blfs/7.6/m/
}
