SUMMARY_packagegroup-sdr-gnuradio-base = "Basic GNU Radio install."
RDEPENDS_packagegroup-sdr-gnuradio-base = "\
    gnuradio \
"


SUMMARY_packagegroup-sdr-rtlsdr = "RTLSDR packages."
RDEPENDS_packagegroup-sdr-rtlsdr = "\
    rtl-sdr \
"

SUMMARY_packagegroup-sdr-gnuradio-extended = "All GNU Radio OOT modules."
RDEPENDS_packagegroup-sdr-gnuradio-extended = ""
